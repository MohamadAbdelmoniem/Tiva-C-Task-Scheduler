# IAR project trytry.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ewarm; PART_TM4C123GH6PM; TARGET_IS_TM4C123_RB1
  ICCARM.CCIncludePath2: C:\ti\TivaWare_C_Series-2.2.0.295
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: trytry.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkAdditionalLibs: C:\ti\TivaWare_C_Series-2.2.0.295\driverlib\ewarm\Exe\driverlib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: bitwise_operation.h Counter.c Counter.h DIO.c DIO.h main.c Schuduler.c Schuduler.h startup_ewarm.c types.h
    ../../ASU/Senior1/Embedded/: tm4c123gh6pm.h
